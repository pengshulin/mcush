# IAR project Project.ewp, settings and files
configuration STM324xG_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\netif; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7\FreeRTOS\; ..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\portable\IAR\ARM_CM3; ..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM324x7I_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F427II ST STM32F427II
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F427X; USE_STM324x7I_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\netif; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7; ..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7\FreeRTOS\; ..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\portable\IAR\ARM_CM3; ..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\include
  group CMSIS
    ../src/: system_stm32f4xx.c
  group EWARM
    ./: startup_stm32f40xx.s startup_stm32f427x.s
  group FreeRTOS
    ../../../../Utilities/Third_Party/FreeRTOSV7.3.0/: croutine.c list.c queue.c tasks.c
  group FreeRTOS/portable
    ../../../../Utilities/Third_Party/FreeRTOSV7.3.0/portable/MemMang/: heap_4.c
    ../../../../Utilities/Third_Party/FreeRTOSV7.3.0/portable/IAR/ARM_CM3/: port.c portasm.s
  group LwIP/Api
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/Core
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LwIP/Core/IPv4
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP/Netif
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/netif/: etharp.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group STM32_EVAL/STM324x7I_EVAL
    ../../../../Utilities/STM32_EVAL/STM324x7I_EVAL/: stm324x7i_eval.c stm324x7i_eval_lcd.c
  group STM32_EVAL/STM324xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_lcd.c
  group STM32F4x7_ETH_Driver
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group User
    ../src/: fs.c httpserver-netconn.c main.c netconf.c serial_debug.c stm32f4x7_eth_bsp.c stm32f4xx_it.c
